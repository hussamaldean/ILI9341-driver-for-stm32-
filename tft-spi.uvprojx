# Keil uVision project tft-spi.uvprojx, settings and files
target STM32F407VETx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tft-spi
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./: main.c Read Me.txt
  group ILI9341
    ./: ILI9341.c ILI9341.h
  group Delay
    ./: delay.c delay.h
  group SPI
    ./: SPI.c SPI.h
  group MPU9250
    ./: MPU9250.c MPU9250.h
  group I2C
    ./: i2c.c i2c.h
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.3
